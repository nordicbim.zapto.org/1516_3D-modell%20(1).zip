Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[notYetAssigned]
File name: IFC4_UTM32_NN2000_no_units.ifc
Time: 2024-05-14T10:25:33
Written by: FME 2021.2.3.0

# IfcGeographicElement, Terrain
In: _ground
PredefinedType: TERRAIN
